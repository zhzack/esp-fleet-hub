#include "lcd_st7789.h"

#include <string.h>
#include <stdio.h>
#include "esp_log.h"
#include "esp_heap_caps.h"
#include "freertos/FreeRTOS.h"
#include "freertos/task.h"
#include "freertos/semphr.h"
#include "driver/gpio.h"
#include "driver/spi_master.h"
#include "esp_lcd_panel_io.h"
#include "esp_lcd_panel_vendor.h"
#include "esp_lcd_panel_ops.h"
#include "wifi_mgr.h"
#include "hid_usb.h"

static const char *TAG = "st7789";

static esp_lcd_panel_handle_t s_panel = NULL;
static SemaphoreHandle_t s_trans_done_sem = NULL;

#define CHUNK_LINES 20
static uint16_t *s_dma_buf = NULL; // 240 * 20 * 2 = 9600 bytes in DMA-capable SRAM

/* Standard 8x16 ASCII font (characters 32 to 126) */
static const uint8_t FONT_8X16[95][16] = {
    {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // ' '
    {0x00,0x00,0x18,0x3c,0x3c,0x3c,0x18,0x18,0x18,0x00,0x18,0x18,0x00,0x00,0x00,0x00}, // '!'
    {0x00,0x66,0x66,0x66,0x24,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // '"'
    {0x00,0x00,0x00,0x6c,0x6c,0xfe,0x6c,0x6c,0x6c,0xfe,0x6c,0x6c,0x00,0x00,0x00,0x00}, // '#'
    {0x18,0x18,0x7c,0xc6,0xc2,0xc0,0x7c,0x06,0x06,0x86,0xc6,0x7c,0x18,0x18,0x00,0x00}, // '$'
    {0x00,0x00,0x00,0x00,0xc2,0xc6,0x0c,0x18,0x30,0x60,0xc6,0x86,0x00,0x00,0x00,0x00}, // '%'
    {0x00,0x00,0x38,0x6c,0x6c,0x38,0x76,0xdc,0xcc,0xcc,0xcc,0x76,0x00,0x00,0x00,0x00}, // '&'
    {0x00,0x30,0x30,0x30,0x60,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // '\''
    {0x00,0x0c,0x18,0x30,0x30,0x60,0x60,0x60,0x60,0x60,0x30,0x30,0x18,0x0c,0x00,0x00}, // '('
    {0x00,0x30,0x18,0x0c,0x0c,0x06,0x06,0x06,0x06,0x06,0x0c,0x0c,0x18,0x30,0x00,0x00}, // ')'
    {0x00,0x00,0x00,0x00,0x66,0x3c,0xff,0x3c,0x66,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // '*'
    {0x00,0x00,0x00,0x18,0x18,0x18,0x7e,0x18,0x18,0x18,0x00,0x00,0x00,0x00,0x00,0x00}, // '+'
    {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x18,0x18,0x18,0x30,0x00,0x00,0x00}, // ','
    {0x00,0x00,0x00,0x00,0x00,0x00,0xfe,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // '-'
    {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x18,0x18,0x00,0x00,0x00,0x00}, // '.'
    {0x00,0x00,0x02,0x06,0x0c,0x18,0x30,0x60,0xc0,0x80,0x00,0x00,0x00,0x00,0x00,0x00}, // '/'
    {0x00,0x00,0x7c,0xc6,0xc6,0xce,0xd6,0xe6,0xc6,0xc6,0xc6,0x7c,0x00,0x00,0x00,0x00}, // '0'
    {0x00,0x00,0x18,0x38,0x78,0x18,0x18,0x18,0x18,0x18,0x18,0x7e,0x00,0x00,0x00,0x00}, // '1'
    {0x00,0x00,0x7c,0xc6,0x06,0x0c,0x18,0x30,0x60,0xc0,0xc6,0xfe,0x00,0x00,0x00,0x00}, // '2'
    {0x00,0x00,0x7c,0xc6,0x06,0x06,0x3c,0x06,0x06,0x06,0xc6,0x7c,0x00,0x00,0x00,0x00}, // '3'
    {0x00,0x00,0x0c,0x1c,0x3c,0x6c,0xcc,0xfe,0x0c,0x0c,0x0c,0x1e,0x00,0x00,0x00,0x00}, // '4'
    {0x00,0x00,0xfe,0xc0,0xc0,0xfc,0x06,0x06,0x06,0x06,0xc6,0x7c,0x00,0x00,0x00,0x00}, // '5'
    {0x00,0x00,0x38,0x60,0xc0,0xc0,0xfc,0xc6,0xc6,0xc6,0xc6,0x7c,0x00,0x00,0x00,0x00}, // '6'
    {0x00,0x00,0xfe,0xc6,0x06,0x06,0x0c,0x18,0x30,0x30,0x30,0x30,0x00,0x00,0x00,0x00}, // '7'
    {0x00,0x00,0x7c,0xc6,0xc6,0xc6,0x7c,0xc6,0xc6,0xc6,0xc6,0x7c,0x00,0x00,0x00,0x00}, // '8'
    {0x00,0x00,0x7c,0xc6,0xc6,0xc6,0xc6,0x7e,0x06,0x06,0x0c,0x78,0x00,0x00,0x00,0x00}, // '9'
    {0x00,0x00,0x00,0x18,0x18,0x00,0x00,0x00,0x00,0x18,0x18,0x00,0x00,0x00,0x00,0x00}, // ':'
    {0x00,0x00,0x00,0x18,0x18,0x00,0x00,0x00,0x00,0x18,0x18,0x30,0x00,0x00,0x00,0x00}, // ';'
    {0x00,0x06,0x0c,0x18,0x30,0x60,0xc0,0x60,0x30,0x18,0x0c,0x06,0x00,0x00,0x00,0x00}, // '<'
    {0x00,0x00,0x00,0x00,0x7e,0x00,0x00,0x7e,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // '='
    {0x00,0x60,0x30,0x18,0x0c,0x06,0x03,0x06,0x0c,0x18,0x30,0x60,0x00,0x00,0x00,0x00}, // '>'
    {0x00,0x00,0x7c,0xc6,0xc6,0x0c,0x18,0x18,0x18,0x00,0x18,0x18,0x00,0x00,0x00,0x00}, // '?'
    {0x00,0x00,0x7c,0xc6,0xc6,0xde,0xde,0xde,0xdc,0xc0,0xc6,0x7c,0x00,0x00,0x00,0x00}, // '@'
    {0x00,0x00,0x10,0x38,0x6c,0xc6,0xc6,0xfe,0xc6,0xc6,0xc6,0xc6,0x00,0x00,0x00,0x00}, // 'A'
    {0x00,0x00,0xfc,0x66,0x66,0x66,0x7c,0x66,0x66,0x66,0x66,0xfc,0x00,0x00,0x00,0x00}, // 'B'
    {0x00,0x00,0x3c,0x66,0xc2,0xc0,0xc0,0xc0,0xc0,0xc2,0x66,0x3c,0x00,0x00,0x00,0x00}, // 'C'
    {0x00,0x00,0xf8,0x6c,0x66,0x66,0x66,0x66,0x66,0x66,0x6c,0xf8,0x00,0x00,0x00,0x00}, // 'D'
    {0x00,0x00,0xfe,0x66,0x62,0x68,0x78,0x68,0x60,0x62,0x66,0xfe,0x00,0x00,0x00,0x00}, // 'E'
    {0x00,0x00,0xfe,0x66,0x62,0x68,0x78,0x68,0x60,0x60,0x60,0xf0,0x00,0x00,0x00,0x00}, // 'F'
    {0x00,0x00,0x3c,0x66,0xc2,0xc0,0xc0,0xde,0xc6,0xc6,0x66,0x3a,0x00,0x00,0x00,0x00}, // 'G'
    {0x00,0x00,0xc6,0xc6,0xc6,0xc6,0xfe,0xc6,0xc6,0xc6,0xc6,0xc6,0x00,0x00,0x00,0x00}, // 'H'
    {0x00,0x00,0x3c,0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x3c,0x00,0x00,0x00,0x00}, // 'I'
    {0x00,0x00,0x1e,0x0c,0x0c,0x0c,0x0c,0x0c,0xcc,0xcc,0xcc,0x78,0x00,0x00,0x00,0x00}, // 'J'
    {0x00,0x00,0xe6,0x66,0x6c,0x68,0x78,0x68,0x6c,0x66,0x66,0xe6,0x00,0x00,0x00,0x00}, // 'K'
    {0x00,0x00,0xf0,0x60,0x60,0x60,0x60,0x60,0x60,0x62,0x66,0xfe,0x00,0x00,0x00,0x00}, // 'L'
    {0x00,0x00,0xc6,0xee,0xfe,0xfe,0xd6,0xc6,0xc6,0xc6,0xc6,0xc6,0x00,0x00,0x00,0x00}, // 'M'
    {0x00,0x00,0xc6,0xe6,0xf6,0xfe,0xde,0xce,0xc6,0xc6,0xc6,0xc6,0x00,0x00,0x00,0x00}, // 'N'
    {0x00,0x00,0x7c,0xc6,0xc6,0xc6,0xc6,0xc6,0xc6,0xc6,0xc6,0x7c,0x00,0x00,0x00,0x00}, // 'O'
    {0x00,0x00,0xfc,0x66,0x66,0x66,0x7c,0x60,0x60,0x60,0x60,0xf0,0x00,0x00,0x00,0x00}, // 'P'
    {0x00,0x00,0x7c,0xc6,0xc6,0xc6,0xc6,0xc6,0xc6,0xd6,0xde,0x7c,0x0c,0x0e,0x00,0x00}, // 'Q'
    {0x00,0x00,0xfc,0x66,0x66,0x66,0x7c,0x6c,0x66,0x66,0x66,0xe6,0x00,0x00,0x00,0x00}, // 'R'
    {0x00,0x00,0x7c,0xc6,0xc6,0x60,0x38,0x0c,0x06,0xc6,0xc6,0x7c,0x00,0x00,0x00,0x00}, // 'S'
    {0x00,0x00,0x7e,0x7e,0x5a,0x18,0x18,0x18,0x18,0x18,0x18,0x3c,0x00,0x00,0x00,0x00}, // 'T'
    {0x00,0x00,0xc6,0xc6,0xc6,0xc6,0xc6,0xc6,0xc6,0xc6,0xc6,0x7c,0x00,0x00,0x00,0x00}, // 'U'
    {0x00,0x00,0xc6,0xc6,0xc6,0xc6,0xc6,0xc6,0xc6,0x6c,0x38,0x10,0x00,0x00,0x00,0x00}, // 'V'
    {0x00,0x00,0xc6,0xc6,0xc6,0xc6,0xd6,0xfe,0xfe,0xee,0xc6,0xc6,0x00,0x00,0x00,0x00}, // 'W'
    {0x00,0x00,0xc6,0xc6,0x6c,0x38,0x10,0x38,0x6c,0xc6,0xc6,0xc6,0x00,0x00,0x00,0x00}, // 'X'
    {0x00,0x00,0x66,0x66,0x66,0x66,0x3c,0x18,0x18,0x18,0x18,0x3c,0x00,0x00,0x00,0x00}, // 'Y'
    {0x00,0x00,0xfe,0xc6,0x8c,0x18,0x30,0x60,0xc0,0x82,0xc6,0xfe,0x00,0x00,0x00,0x00}, // 'Z'
    {0x00,0x3c,0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x3c,0x00,0x00,0x00,0x00}, // '['
    {0x00,0x00,0x80,0xc0,0x60,0x30,0x18,0x0c,0x06,0x02,0x00,0x00,0x00,0x00,0x00,0x00}, // '\'
    {0x00,0x3c,0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,0x3c,0x00,0x00,0x00,0x00}, // ']'
    {0x10,0x38,0x6c,0xc6,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // '^'
    {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xff}, // '_'
    {0x30,0x30,0x18,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // '`'
    {0x00,0x00,0x00,0x00,0x00,0x78,0x0c,0x7c,0xcc,0xcc,0xcc,0x76,0x00,0x00,0x00,0x00}, // 'a'
    {0x00,0x00,0xe0,0x60,0x60,0x78,0x6c,0x66,0x66,0x66,0x66,0x7b,0x00,0x00,0x00,0x00}, // 'b'
    {0x00,0x00,0x00,0x00,0x00,0x3c,0x66,0xc0,0xc0,0xc0,0x66,0x3c,0x00,0x00,0x00,0x00}, // 'c'
    {0x00,0x00,0x1c,0x0c,0x0c,0x3c,0x6c,0xcc,0xcc,0xcc,0xcc,0x76,0x00,0x00,0x00,0x00}, // 'd'
    {0x00,0x00,0x00,0x00,0x00,0x7c,0xc6,0xfe,0xc0,0xc0,0x66,0x3c,0x00,0x00,0x00,0x00}, // 'e'
    {0x00,0x00,0x38,0x6c,0x64,0x60,0xf0,0x60,0x60,0x60,0x60,0xf0,0x00,0x00,0x00,0x00}, // 'f'
    {0x00,0x00,0x00,0x00,0x00,0x76,0xcc,0xcc,0xcc,0xcc,0x7c,0x0c,0xcc,0x78,0x00,0x00}, // 'g'
    {0x00,0x00,0xe0,0x60,0x60,0x6c,0x76,0x66,0x66,0x66,0x66,0xe6,0x00,0x00,0x00,0x00}, // 'h'
    {0x00,0x00,0x18,0x18,0x00,0x38,0x18,0x18,0x18,0x18,0x18,0x3c,0x00,0x00,0x00,0x00}, // 'i'
    {0x00,0x00,0x0c,0x0c,0x00,0x1c,0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,0xcc,0x78,0x00,0x00}, // 'j'
    {0x00,0x00,0xe0,0x60,0x60,0x66,0x6c,0x78,0x78,0x6c,0x66,0xe6,0x00,0x00,0x00,0x00}, // 'k'
    {0x00,0x00,0x38,0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x3c,0x00,0x00,0x00,0x00}, // 'l'
    {0x00,0x00,0x00,0x00,0x00,0xec,0xfe,0xd6,0xd6,0xd6,0xd6,0xc6,0x00,0x00,0x00,0x00}, // 'm'
    {0x00,0x00,0x00,0x00,0x00,0xdc,0x66,0x66,0x66,0x66,0x66,0x66,0x00,0x00,0x00,0x00}, // 'n'
    {0x00,0x00,0x00,0x00,0x00,0x7c,0xc6,0xc6,0xc6,0xc6,0xc6,0x7c,0x00,0x00,0x00,0x00}, // 'o'
    {0x00,0x00,0x00,0x00,0x00,0xdc,0x66,0x66,0x66,0x66,0x7c,0x60,0x60,0xf0,0x00,0x00}, // 'p'
    {0x00,0x00,0x00,0x00,0x00,0x76,0xcc,0xcc,0xcc,0xcc,0x7c,0x0c,0x0c,0x1e,0x00,0x00}, // 'q'
    {0x00,0x00,0x00,0x00,0x00,0xdc,0x76,0x66,0x60,0x60,0x60,0xf0,0x00,0x00,0x00,0x00}, // 'r'
    {0x00,0x00,0x00,0x00,0x00,0x7c,0xc6,0x60,0x38,0x0c,0xc6,0x7c,0x00,0x00,0x00,0x00}, // 's'
    {0x00,0x00,0x10,0x30,0x30,0xfc,0x30,0x30,0x30,0x30,0x34,0x18,0x00,0x00,0x00,0x00}, // 't'
    {0x00,0x00,0x00,0x00,0x00,0xcc,0xcc,0xcc,0xcc,0xcc,0xcc,0x76,0x00,0x00,0x00,0x00}, // 'u'
    {0x00,0x00,0x00,0x00,0x00,0xc6,0xc6,0xc6,0xc6,0xc6,0x6c,0x38,0x00,0x00,0x00,0x00}, // 'v'
    {0x00,0x00,0x00,0x00,0x00,0xc6,0xc6,0xd6,0xd6,0xfe,0xee,0x6c,0x00,0x00,0x00,0x00}, // 'w'
    {0x00,0x00,0x00,0x00,0x00,0xc6,0x6c,0x38,0x38,0x6c,0xc6,0xc6,0x00,0x00,0x00,0x00}, // 'x'
    {0x00,0x00,0x00,0x00,0x00,0xc6,0xc6,0xc6,0xc6,0xc6,0x7e,0x06,0x0c,0x78,0x00,0x00}, // 'y'
    {0x00,0x00,0x00,0x00,0x00,0xfe,0xcc,0x18,0x30,0x60,0xc6,0xfe,0x00,0x00,0x00,0x00}, // 'z'
    {0x00,0x0e,0x18,0x18,0x18,0x70,0x18,0x18,0x18,0x18,0x18,0x0e,0x00,0x00,0x00,0x00}, // '{'
    {0x00,0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x00,0x00,0x00,0x00}, // '|'
    {0x00,0x70,0x18,0x18,0x18,0x0e,0x18,0x18,0x18,0x18,0x18,0x70,0x00,0x00,0x00,0x00}, // '}'
    {0x76,0xdc,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // '~'
};

static bool on_trans_done_cb(esp_lcd_panel_io_handle_t panel_io, esp_lcd_panel_io_event_data_t *edata, void *user_ctx)
{
    BaseType_t high_task_awoken = pdFALSE;
    if (s_trans_done_sem) {
        xSemaphoreGiveFromISR(s_trans_done_sem, &high_task_awoken);
    }
    return high_task_awoken == pdTRUE;
}

static void draw_bitmap_sync(int x_start, int y_start, int x_end, int y_end, const void *color_data)
{
    if (!s_panel) return;
    esp_lcd_panel_draw_bitmap(s_panel, x_start, y_start, x_end, y_end, color_data);
    if (s_trans_done_sem) {
        xSemaphoreTake(s_trans_done_sem, pdMS_TO_TICKS(500));
    }
}

esp_err_t lcd_st7789_init(void)
{
    if (s_panel) return ESP_OK;

    ESP_LOGI(TAG, "Initializing ST7789 LCD (MOSI=%d, SCLK=%d, DC=%d, RST=%d, CS=%d)...",
             LCD_PIN_MOSI, LCD_PIN_SCLK, LCD_PIN_DC, LCD_PIN_RST, LCD_PIN_CS);

    s_trans_done_sem = xSemaphoreCreateBinary();
    s_dma_buf = heap_caps_malloc(LCD_WIDTH * CHUNK_LINES * sizeof(uint16_t), MALLOC_CAP_DMA | MALLOC_CAP_INTERNAL);
    if (!s_dma_buf) {
        ESP_LOGE(TAG, "Failed to allocate DMA buffer in internal SRAM");
        return ESP_ERR_NO_MEM;
    }

    spi_bus_config_t buscfg = {
        .sclk_io_num = LCD_PIN_SCLK,
        .mosi_io_num = LCD_PIN_MOSI,
        .miso_io_num = -1,
        .quadwp_io_num = -1,
        .quadhd_io_num = -1,
        .max_transfer_sz = LCD_WIDTH * CHUNK_LINES * sizeof(uint16_t),
    };
    esp_err_t err = spi_bus_initialize(SPI2_HOST, &buscfg, SPI_DMA_CH_AUTO);
    if (err != ESP_OK && err != ESP_ERR_INVALID_STATE) {
        ESP_LOGE(TAG, "spi_bus_initialize failed: %s", esp_err_to_name(err));
        return err;
    }

    esp_lcd_panel_io_handle_t io_handle = NULL;
    esp_lcd_panel_io_spi_config_t io_config = {
        .dc_gpio_num = LCD_PIN_DC,
        .cs_gpio_num = LCD_PIN_CS,
        .pclk_hz = 20 * 1000 * 1000, // 20MHz for signal integrity on Dupont wires
        .lcd_cmd_bits = 8,
        .lcd_param_bits = 8,
        .spi_mode = 0,
        .trans_queue_depth = 10,
    };
    err = esp_lcd_new_panel_io_spi((esp_lcd_spi_bus_handle_t)SPI2_HOST, &io_config, &io_handle);
    if (err != ESP_OK) {
        ESP_LOGE(TAG, "esp_lcd_new_panel_io_spi failed: %s", esp_err_to_name(err));
        return err;
    }

    esp_lcd_panel_io_callbacks_t cbs = {
        .on_color_trans_done = on_trans_done_cb,
    };
    esp_lcd_panel_io_register_event_callbacks(io_handle, &cbs, NULL);

    esp_lcd_panel_dev_config_t panel_config = {
        .reset_gpio_num = LCD_PIN_RST,
        .rgb_endian = LCD_RGB_ENDIAN_BGR,
        .bits_per_pixel = 16,
    };
    err = esp_lcd_new_panel_st7789(io_handle, &panel_config, &s_panel);
    if (err != ESP_OK) {
        ESP_LOGE(TAG, "esp_lcd_new_panel_st7789 failed: %s", esp_err_to_name(err));
        return err;
    }

    esp_lcd_panel_reset(s_panel);
    esp_lcd_panel_init(s_panel);
    esp_lcd_panel_invert_color(s_panel, true); // IPS invert color ON (0x21)
    esp_lcd_panel_set_gap(s_panel, 0, 0);
    esp_lcd_panel_disp_on_off(s_panel, true);

    ESP_LOGI(TAG, "ST7789 LCD initialized successfully (240x240, 16-bit color, DMA-sync)");
    lcd_st7789_test_pattern();
    return ESP_OK;
}

void lcd_st7789_fill(uint16_t color)
{
    if (!s_panel || !s_dma_buf) return;
    int total_pixels = LCD_WIDTH * CHUNK_LINES;
    for (int i = 0; i < total_pixels; i++) s_dma_buf[i] = color;

    for (int y = 0; y < LCD_HEIGHT; y += CHUNK_LINES) {
        draw_bitmap_sync(0, y, LCD_WIDTH, y + CHUNK_LINES, s_dma_buf);
    }
}

void lcd_st7789_fill_rect(int x, int y, int w, int h, uint16_t color)
{
    if (!s_panel || !s_dma_buf || w <= 0 || h <= 0) return;
    if (x + w > LCD_WIDTH) w = LCD_WIDTH - x;
    if (y + h > LCD_HEIGHT) h = LCD_HEIGHT - y;

    for (int i = 0; i < w; i++) s_dma_buf[i] = color;
    for (int cy = y; cy < y + h; cy++) {
        draw_bitmap_sync(x, cy, x + w, cy + 1, s_dma_buf);
    }
}

void lcd_st7789_draw_string(int x, int y, const char *str, uint16_t fg, uint16_t bg)
{
    if (!s_panel || !s_dma_buf || !str) return;
    int len = strlen(str);
    if (len == 0) return;

    int char_w = 8, char_h = 16;
    int total_w = len * char_w;
    if (x + total_w > LCD_WIDTH) total_w = LCD_WIDTH - x;
    if (total_w <= 0 || y + char_h > LCD_HEIGHT) return;

    for (int cy = 0; cy < char_h; cy++) {
        for (int i = 0; i < len; i++) {
            char c = str[i];
            uint8_t row = 0;
            if (c >= 32 && c <= 126) {
                row = FONT_8X16[c - 32][cy];
            }
            for (int cx = 0; cx < char_w; cx++) {
                int px = i * char_w + cx;
                if (px < total_w) {
                    s_dma_buf[cy * total_w + px] = (row & (0x80 >> cx)) ? fg : bg;
                }
            }
        }
    }

    draw_bitmap_sync(x, y, x + total_w, y + char_h, s_dma_buf);
}

void lcd_st7789_draw_string_2x(int x, int y, const char *str, uint16_t fg, uint16_t bg)
{
    if (!s_panel || !s_dma_buf || !str) return;
    int len = strlen(str);
    if (len == 0) return;

    for (int i = 0; i < len; i++) {
        char c = str[i];
        if (c < 32 || c > 126) continue;
        int cx_pos = x + i * 16;
        if (cx_pos + 16 > LCD_WIDTH) break;

        for (int cy = 0; cy < 16; cy++) {
            uint8_t row = FONT_8X16[c - 32][cy];
            for (int cx = 0; cx < 8; cx++) {
                uint16_t col = (row & (0x80 >> cx)) ? fg : bg;
                s_dma_buf[(cy * 2) * 16 + (cx * 2)] = col;
                s_dma_buf[(cy * 2) * 16 + (cx * 2 + 1)] = col;
                s_dma_buf[(cy * 2 + 1) * 16 + (cx * 2)] = col;
                s_dma_buf[(cy * 2 + 1) * 16 + (cx * 2 + 1)] = col;
            }
        }
        draw_bitmap_sync(cx_pos, y, cx_pos + 16, y + 32, s_dma_buf);
    }
}

void lcd_st7789_show_dashboard(const char *ip, const char *ssid, bool usb_ok, uint32_t free_heap)
{
    if (!s_panel) return;

    // Header bar (Navy)
    lcd_st7789_fill_rect(0, 0, LCD_WIDTH, 36, LCD_COLOR_NAVY);
    lcd_st7789_draw_string(24, 10, "ESP32-S3 LAN KVM", LCD_COLOR_CYAN, LCD_COLOR_NAVY);

    // Body background
    lcd_st7789_fill_rect(0, 36, LCD_WIDTH, LCD_HEIGHT - 36, LCD_COLOR_BLACK);

    // Card 1: IP Address
    lcd_st7789_fill_rect(10, 48, LCD_WIDTH - 20, 42, 0x18E3); // Dark slate
    lcd_st7789_draw_string(20, 54, "DEVICE IP:", LCD_COLOR_GRAY, 0x18E3);
    lcd_st7789_draw_string(20, 70, ip ? ip : "Connecting...", LCD_COLOR_YELLOW, 0x18E3);

    // Card 2: Wi-Fi status
    lcd_st7789_fill_rect(10, 98, LCD_WIDTH - 20, 36, 0x18E3);
    char wifi_buf[32];
    snprintf(wifi_buf, sizeof(wifi_buf), "WiFi: %s", ssid ? ssid : "None");
    lcd_st7789_draw_string(20, 108, wifi_buf, LCD_COLOR_WHITE, 0x18E3);

    // Card 3: USB HID & Memory
    lcd_st7789_fill_rect(10, 142, LCD_WIDTH - 20, 48, 0x18E3);
    char usb_buf[32];
    snprintf(usb_buf, sizeof(usb_buf), "USB: %s", usb_ok ? "HID+CDC Online" : "Disconnected");
    lcd_st7789_draw_string(20, 150, usb_buf, usb_ok ? LCD_COLOR_GREEN : LCD_COLOR_RED, 0x18E3);

    char mem_buf[32];
    snprintf(mem_buf, sizeof(mem_buf), "Heap: %.1f MB Free", (float)free_heap / (1024.0f * 1024.0f));
    lcd_st7789_draw_string(20, 168, mem_buf, LCD_COLOR_CYAN, 0x18E3);

    // Bottom Decorative Bar
    uint16_t colors[] = {LCD_COLOR_RED, LCD_COLOR_YELLOW, LCD_COLOR_GREEN, LCD_COLOR_CYAN, LCD_COLOR_BLUE, LCD_COLOR_MAGENTA};
    int bar_w = LCD_WIDTH / 6;
    for (int i = 0; i < 6; i++) {
        lcd_st7789_fill_rect(i * bar_w, 206, bar_w, 18, colors[i]);
    }

    lcd_st7789_draw_string(60, 226, "esp32-headless", LCD_COLOR_DARKGRAY, LCD_COLOR_BLACK);
}

void lcd_st7789_test_pattern(void)
{
    if (!s_panel) return;
    lcd_st7789_fill(LCD_COLOR_BLACK);
    char ip[16] = {0};
    wifi_mgr_get_ip(ip, sizeof(ip));
    char ssid[33] = {0};
    wifi_mgr_get_ssid(ssid, sizeof(ssid));
    bool usb = hid_usb_mounted();
    uint32_t heap = esp_get_free_heap_size();
    lcd_st7789_show_dashboard(ip[0] ? ip : "192.168.68.143", ssid[0] ? ssid : "1", usb, heap);
}
